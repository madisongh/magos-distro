SRC_URI_remove = "file://0001-gfx-direct-Aboid-usng-VLAs-and-printf-formats.patch"
