OPENGL_PKGCONFIGS_imxgpu2d = "dri glx"
PACKAGE_ARCH_imxgpu2d = "${MACHINE_ARCH}"
