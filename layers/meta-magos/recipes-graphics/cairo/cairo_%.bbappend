PACKAGECONFIG_class-native = ""
