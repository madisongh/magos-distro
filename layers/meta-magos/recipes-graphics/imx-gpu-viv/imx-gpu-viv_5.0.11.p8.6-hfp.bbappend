do_install_append() {
	rm -rf ${D}${includedir}/KHR
}
