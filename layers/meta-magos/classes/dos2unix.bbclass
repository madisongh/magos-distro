../../../repos/meta-openembedded/meta-oe/classes/dos2unix.bbclass