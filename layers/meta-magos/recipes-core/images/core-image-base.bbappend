CORE_IMAGE_EXTRA_INSTALL = "\
    bash \
    mtd-utils \
    coreutils \
    mmc-utils \
    procps \
    lsb \
    lsbinitscripts \
    dosfstools \
    e2fsprogs \
    parted \
    util-linux \
    "