RDEPENDS_packagegroup-core-full-cmdline-sys-services_remove = "nfs-utils"
