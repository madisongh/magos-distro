FILESEXTRAPATHS_prepend := "${THISDIR}/gcc:"
SRC_URI += "file://backport-use-ucontext-t-not-struct-ucontext.patch"
