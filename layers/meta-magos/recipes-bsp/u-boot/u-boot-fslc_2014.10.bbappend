FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-fslc-2014.10:"

SRC_URI += "file://quietboot.patch"
