SRC_URI = "git://github.com/madisongh/u-boot-fslc;branch=${SRCBRANCH}"
SRCBRANCH = "magos-2016.09+fslc"
SRCREV = "${AUTOREV}"
