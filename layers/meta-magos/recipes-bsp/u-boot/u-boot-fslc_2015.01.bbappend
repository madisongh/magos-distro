FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-fslc-2015.01:"

SRC_URI += "file://quietboot.patch"
