SRC_URI = "git://github.com/madisongh/u-boot-fslc;branch=${SRCBRANCH}"
SRCBRANCH = "magos-dev"
SRCREV = "${AUTOREV}"
