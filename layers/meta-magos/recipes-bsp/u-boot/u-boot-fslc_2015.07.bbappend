SRC_URI = "git://github.com/madisongh/u-boot-fslc;branch=${SRCBRANCH}"
SRCBRANCH = "magos-2015.07+fslc"
SRCREV = "${AUTOREV}"
