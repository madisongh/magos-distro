KERNEL_MODULE_AUTOLOAD_append_wandboard-quad = " cryptodev"
