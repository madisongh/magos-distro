FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
WANDBOARD_GITHUB_MIRROR = "git://github.com/madisongh/linux"
SRCREV = "751b84948edddbd3d7a441bb8f759546413a1954"
